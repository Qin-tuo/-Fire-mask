# Keil uVision project STM32103FZET6_FreeRTOS.uvprojx, settings and files
target STM32F103ZET6_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32103FZET6_FreeRTOS +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\STM32FLib\CMSIS\CoreSupport;..\STM32FLib\CMSIS\DeviceSupport;..\STM32FLib\inc;..\STM32FLib\USER;..\System\delay;..\System\sys;..\System\usart;..\Hardware\ADC;..\Hardware\KEY;..\Hardware\LCD;..\Hardware\LED;..\Hardware\SPI;..\Hardware\TIMER;..\System;..\APP\start_task;..\FreeRTOS;..\FreeRTOS\include;..\APP\start_task;..\FreeRTOS\portable\RVDS\ARM_CM3;..\APP\led_task;..\Hardware\DHT11;..\Hardware\MPU6050;..\Hardware\GPS;..\Hardware\USART3;..\Hardware\TIMER7;..\APP\lcd_task;..\APP\test_task;..\APP\sensor_task;..\Hardware\OV7670;..\Hardware\EXTI;..\Hardware\BEEP;..\APP\camera_task;..\Hardware\TIMER6;..\USMART;..\APP\print_task;..\Hardware\Picture;..\Hardware\DMA;..\Hardware\MPU6050\eMPL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../STM32FLib/USER/: main.c stm32f10x_it.c
  group CMSIS
    ../STM32FLib/CMSIS/CoreSupport/: core_cm3.c
    ../STM32FLib/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Startup
    ../STM32FLib/startup/: startup_stm32f10x_hd.s
  group Libraries
    ../STM32FLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Hardware
    ../Hardware/ADC/: adc.c
    ../Hardware/KEY/: key.c
    ../Hardware/LCD/: lcd.c
    ../Hardware/LED/: led.c
    ../Hardware/DHT11/: dht11.c
    ../Hardware/MPU6050/: mpu6050.c mpuiic.c
    ../Hardware/GPS/: gps.c
    ../Hardware/USART3/: usart3.c
    ../Hardware/TIMER7/: timer7.c
    ../Hardware/OV7670/: ov7670.c sccb.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/BEEP/: beep.c
    ../Hardware/TIMER6/: timer6.c
    ../Hardware/Picture/: Pic_Process.c
    ../Hardware/DMA/: dma.c
    ../../../工作/消防口罩  3500/6.24 整合/Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group APP
    ../APP/start_task/: start_task.c
    ../APP/led_task/: led_task.c
    ../APP/lcd_task/: lcd_task.c
    ../APP/sensor_task/: sensor_task.c
    ../APP/camera_task/: camera_task.c
    ../APP/print_task/: print_task.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
software components: CMSIS:CORE 5.2.0
